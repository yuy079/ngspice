.inc 'inc-3.cir'

v21 21 0 DC=102.01
