* -*- spice -*-

.lib SUBR
R2 n1 0 2k
.endl
