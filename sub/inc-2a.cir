.inc 'inc-4.cir'

v22 22 0 DC=102.02
