* nupa

* (exec-spice "ngspice -b %s")
*
* check boolean truth

.op

v1100  1100 0  ' 1.01 ? 1101 : 1100'
v1200  1200 0  ' 1.00 ? 1201 : 1200'
v1300  1300 0  ' 0.99 ? 1301 : 1300'

v2100  2100 0  ' 0.51 ? 2101 : 2100'
v2200  2200 0  ' 0.50 ? 2201 : 2200'
v2300  2300 0  ' 0.49 ? 2301 : 2300'

v3100  3100 0  ' 0.02 ? 3101 : 3100'
v3200  3200 0  ' 0.00 ? 3201 : 3200'
v3300  3300 0  '-0.01 ? 3301 : 3300'

v4100  4100 0  '-0.49 ? 4101 : 4100'
v4200  4200 0  '-0.50 ? 4201 : 4200'
v4300  4300 0  '-0.51 ? 4301 : 4300'

v5100  5100 0  '-0.99 ? 5101 : 5100'
v5200  5200 0  '-1.00 ? 5201 : 5200'
v5300  5300 0  '-1.01 ? 5301 : 5300'

.endc
